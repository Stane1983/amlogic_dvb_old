## Kconfig
```kconfig
#
# vs_frontend configuration
#
config VS_FRONTEND
        tristate "vs demod driver"
        default n
        help
        Select to enable vs_frontend demod driver.
```
